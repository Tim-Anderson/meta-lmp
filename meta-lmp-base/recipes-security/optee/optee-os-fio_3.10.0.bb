require optee-os-fio.inc

PV = "3.10.0+git"
SRCREV = "235c0a5a0ec56c276a9ac72656b53d0841cf7468"
SRCBRANCH = "3.10+fio"
